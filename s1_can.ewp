# IAR project s1_can.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\CMSIS\Include; user; module\systick; user\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s1_can.srec
  ILINK.IlinkOutputFile: s1_can.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Device/STM32F4xx/Source/asm_iar/: startup_stm32f40_41xxx.s
    Libraries/CMSIS/Device/STM32F4xx/Source/: system_stm32f4xx.c
  group lib
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group module/systick
    module/systick/: systick.c
  group User
    user/: main.c
    user/src/: sys.c systemcommon.c timer.c
